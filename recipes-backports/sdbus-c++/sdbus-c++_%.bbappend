SRCREV = "7450515d0bc632b871d0d3f549ddb24783dd008f"
PV = "v1.6.0"
SRC_URI = "git://github.com/Kistler-Group/sdbus-cpp.git;protocol=https;branch=master"
