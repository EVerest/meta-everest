inherit everest_internal_base

python __anonymous() {
    bb.error("This class should be overridden")
}